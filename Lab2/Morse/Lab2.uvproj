# Keil uVision project Lab2.uvproj, settings and files
target Internal Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Lab2
  c flags: Optim=1 wLevel=2
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group src
    ./src/: main.c states.c hardwaretimer.c button.c displaystate.c
  group System
    ./src/System/: GLCD_SPI_LPC1700.c system_LPC17xx.c startup_LPC17xx.s
